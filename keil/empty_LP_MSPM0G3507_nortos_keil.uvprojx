# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\src;..\src\config;..\src\drivers;..\src\app;..\src\utils;..\src\isr;..\
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ./: startup_mspm0g350x_uvision.s
    ../src/: config.h
    ../: empty.c empty.syscfg
  group app
    ../src/app/: app_camera_uart.c app_camera_uart.h app_chassis_task.c app_chassis_task.h app_oled_display.c app_oled_display.h key_logic.c key_logic.h app_task_manager.c app_task_manager.h app_path_planner.c app_path_planner.h app_task_1_line_tracking.c app_task_1_line_tracking.h app_task_2_dual_point.c app_task_2_dual_point.h app_task_3_round_trip.c app_task_3_round_trip.h app_task_4_digit_recognition.c app_task_4_digit_recognition.h app_task_5_recognize_transport.c app_task_5_recognize_transport.h app_task_6_auto_transport.c app_task_6_auto_transport.h app_task_7_batch_transport.c app_task_7_batch_transport.h app_task_8_creative.c app_task_8_creative.h
  group config
    ../: ti_msp_dl_config.c ti_msp_dl_config.h
  group drivers
    ../src/drivers/: drv_buzzer.c drv_buzzer.h drv_led.c drv_led.h drv_motor.c drv_motor.h drv_uart.c drv_uart.h drv_jy61p.c drv_jy61p.h drv_encoder.c drv_encoder.h drv_chassis.c drv_chassis.h oled.c oled.h oledfont.h drv_key.c drv_key.h
  group isr
    ../src/isr/: isr_uart.c isr_jy61p.c isr_encoder.c
  group utils
    ../src/utils/: timer.c timer.h pid.c pid.h
